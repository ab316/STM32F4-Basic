# IAR project Bare.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCIncludePath2: C:\Users\Admin\Downloads\STMF4 Discovery\IAR\Discovery1\Bare\Drivers\Peripherals\Include\; C:\Users\Admin\Downloads\STMF4 Discovery\IAR\Discovery1\Bare\Drivers\CMSIS\Include\; C:\Users\Admin\Downloads\STMF4 Discovery\IAR\Discovery1\Bare\Include\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: Bare.srec
  ILINK.IlinkOutputFile: Bare.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Drivers/CMSIS/Include
    ../Drivers/CMSIS/Include/: arm_common_tables.h arm_math.h core_cm0.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h stm32f4xx.h system_stm32f4xx.h
  group Drivers/CMSIS/Source
    ../Drivers/CMSIS/Source/: system_stm32f4xx.c
  group Drivers/Peripherals/Include
    ../Drivers/Peripherals/Include/: misc.h stm32f4xx_dbgmcu.h stm32f4xx_exti.h stm32f4xx_gpio.h stm32f4xx_rcc.h stm32f4xx_syscfg.h stm32f4xx_tim.h
  group Drivers/Peripherals/Source
    ../Drivers/Peripherals/Source/: misc.c stm32f4xx_dbgmcu.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c
  group System
    ../Source/: startup_stm32f4xx.s
    ../Include/: stm32f4xx_conf.h
  group User/Include
    ../Include/: basic1.h basic2.h basic3.h basic4.h basic5.h basic6.h basic7.h basic8.h interrupt.h main.h stdafx.h
  group User/Source
    ../Source/: basic1.c basic2.c basic3.c basic4.c basic5.c basic6.c basic7.c basic8.c interrupt.c main.c
